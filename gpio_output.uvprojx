# Keil uVision project gpio_output.uvprojx, settings and files
target gpio_output_Release (6070000::V6.7::.\ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ESEL ELITTLE
  output: gpio_output
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: .\Inc;.\miku666\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ./source/: interrupts_hc32f005.c system_hc32f005.c
  group source
    ./source/: main.c
  group driver
    ./source/: ddl.c gpio.c sysctrl.c adc.c uart.c
  group README
    ../: readme.txt
  group miku666
    ./miku666/Src/: calibration.c cmd_basic.c cmd_buzzer.c cmd_cal.c cmd_direction.c cmd_help.c cmd_ramp.c cmd_self_test.c cmd_start.c cmd_timer.c instruction_manager.c
software components: CMSIS:CORE 4.1.0
